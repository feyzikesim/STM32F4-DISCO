# Keil uVision project multi-sensor.uvprojx, settings and files
target Multi-Sensor (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: multi-sensor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Project Files
    ./: main.c periph_configurations.h user_defines.h
  group User Libraries
    ./: delay.h unused_functions.txt
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Coroutines 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Message Buffer 10.2.0, RTOS:Stream Buffer 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, CMSIS:RTOS:FreeRTOS 10.2.0, CMSIS:RTOS2:FreeRTOS 10.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
